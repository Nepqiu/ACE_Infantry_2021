# Keil uVision project Project_F407.uvprojx, settings and files
target Project_F407 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project_F407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\sysInit;..\CONTROL\CAN_receive;..\CONTROL\chassis_behaviour;..\CONTROL\gimbal_behaviour;..\CONTROL\IMU;..\CONTROL\MATH;..\CONTROL\RemoteControl;..\CONTROL\RMMOTOR;..\DEFINE;..\HARDWARE\CAN;..\HARDWARE\IWDG;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\PHOTOELECTRIC;..\HARDWARE\PID;..\HARDWARE\TIME;..\HARDWARE\USART;..\REFEREE;..\TASK\Task_Chassis;..\TASK\Task_Detect;..\TASK\Task_Gimbal;..\TASK\Task_Remote;..\TASK\Task_Safe_check;..\TASK\Task_Start;..\CONTROL\MATH\filter;..\CONTROL\MATH\maths;..\TASK\Task_Test
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group SYSTEM
    ../SYSTEM/sysInit/: SysInit.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PHOTOELECTRIC/: photoelectric.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/TIME/: time.c
    ../HARDWARE/USART/: usart.c
  group DEFINRE
    ../DEFINE/: Mode_Def.h PID_Def.h Speed_Def.h
  group CONTROL
    ../CONTROL/CAN_receive/: CAN_receive.c
    ../CONTROL/chassis_behaviour/: chassis_behaviour.c
    ../CONTROL/gimbal_behaviour/: gimbal_behaviour.c
    ../CONTROL/IMU/: IMU.c
    ../CONTROL/MATH/filter/: filter.c
    ../CONTROL/MATH/maths/: maths.c
    ../CONTROL/RemoteControl/: RemoteControl.c
    ../CONTROL/RMMOTOR/: rmmotor.c
  group TASK
    ../TASK/Task_Start/: Task_Start.c
    ../TASK/Task_Remote/: Task_Remote.c
    ../TASK/Task_Chassis/: Task_Chassis.c
    ../TASK/Task_Gimbal/: Task_Gimbal.c
    ../TASK/Task_Detect/: Task_Detect.c
    ../TASK/Task_Safe_check/: Task_Safecheck.c
    ../TASK/Task_Test/: Task_Test.c
